options:
  parameters:
    author: sirius
    generate_options: qt_gui
    id: modulator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: sample_rate/2
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: lo_frequency
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: sample_rate
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_quadrature_demod_cf_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: buffer_size
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: lo_frequency
    fftsize: '8192'
    int_max: '50'
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '2000000'
    center_freq: lo_frequency
    dev_args: 192.168.2.1
    gain: '70'
    samp_rate: sample_rate
    type: fc32
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', qtgui_histogram_sink_x_0, '0']
- [analog_quadrature_demod_cf_2, '0', qtgui_number_sink_0, '0']
- [soapy_plutosdr_source_0, '0', analog_quadrature_demod_cf_1, '0']
- [soapy_plutosdr_source_0, '0', analog_quadrature_demod_cf_2, '0']
- [soapy_plutosdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
