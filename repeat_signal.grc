options:
  parameters:
    author: sirius
    generate_options: qt_gui
    id: repeat_signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: lo_frequency
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sirius/Documents/SDR/recieved_gfsk_signal.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/sirius/Documents/SDR/recieved_signal.bin
    repeat: 'True'
    type: float
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: bandwidth
    center_freq: lo_frequency
    samp_rate: sample_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_sink_0_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: bandwidth
    center_freq: lo_frequency
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', soapy_plutosdr_sink_0_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_file_source_0_0, '0', analog_phase_modulator_fc_0, '0']
- [digital_gfsk_mod_0, '0', soapy_plutosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
