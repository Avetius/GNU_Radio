options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: '4000000'
    center_freq: '868000000'
    gain: '70'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '4000000'
    center_freq: '868000000'
    gain: '70'
    maxoutbuf: '4096'
    minoutbuf: '4096'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', soapy_plutosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
